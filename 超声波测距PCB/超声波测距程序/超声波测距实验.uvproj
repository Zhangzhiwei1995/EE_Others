# Keil uVision project 超声波测距实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 超声波测距实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 超声波测距实验.c
